options:
  parameters:
    author: Vasilina
    generate_options: qt_gui
    id: cubimrtlsdr
    output_language: python
    title: receiver
  states: {}

blocks:
- name: fir_decimation
  id: variable
  parameters:
    value: sdr_samp_rate//fir_samp_rate
  states: {}
- name: fir_freq
  id: variable
  parameters:
    value: sdr_freq+fir_offset
  states: {}
- name: fir_freq_correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Frequency shift (Hz)
    start: '-3000'
    step: '100'
    stop: '+3000'
    value: '0'
  states: {}
- name: fir_offset
  id: variable
  parameters:
    value: sig_freq-sdr_freq+fir_freq_correction
  states: {}
- name: fir_samp_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: fir_samp_rate
  id: variable
  parameters:
    value: sig_baudrate*fir_samp_per_sym
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: ' firdes.low_pass(1,sdr_samp_rate,sdr_samp_rate/(2*fir_decimation), fir_transition_bw)'
  states: {}
- name: fir_transition_bw
  id: variable
  parameters:
    value: sig_baudrate
  states: {}
- name: sdr_freq
  id: variable
  parameters:
    value: sig_freq+sdr_freq_offset
  states: {}
- name: sdr_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: SDR carrier frequency shift (Hz)
    start: '-500000'
    step: '1000'
    stop: '+500000'
    value: '0'
  states: {}
- name: sdr_samp_per_sym
  id: variable
  parameters:
    value: sdr_samp_rate/sig_baudrate
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sig_baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: sig_freq
  id: variable
  parameters:
    value: '433847000'
  states: {}
- name: squelch_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,2
    label: Squelch threshold (dB)
    start: '-100'
    step: '1'
    stop: '+0'
    value: '-58'
    widget: dial
  states: {}
- name: sync_gain_mu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: sync_gain_omega
  id: variable
  parameters:
    value: 0.5 * sync_gain_mu * sync_gain_mu
  states: {}
- name: sync_mu
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: sync_omega_limit
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.bin
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sdr_samp_rate
    type: complex
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    modulus: '0'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: sync_gain_mu
    mu: sync_mu
    omega_relative_limit: sync_omega_limit
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '32'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: fir_offset
    decim: fir_decimation
    samp_rate: sdr_samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '9999'
    type: UDP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: G3RUH
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: sdr_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    name: '"SDR SPECTRE"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fir_samp_rate
    fc: fir_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,1,1,1
    name: '"XLAT SPECTRE"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sdr_samp_rate
    fc: sdr_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    int_max: '-10'
    int_min: '-80'
    name: '"SDR WATERFALL"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fir_samp_rate
    fc: fir_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,1
    int_max: '-10'
    int_min: '-80'
    name: '"XLAT WATERFALL"'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: sig_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sdr_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_gfsk_demod_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_descrambler_bb_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_gfsk_demod_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print]
- [digital_hdlc_deframer_bp_0, out, network_socket_pdu_0, pdus]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
