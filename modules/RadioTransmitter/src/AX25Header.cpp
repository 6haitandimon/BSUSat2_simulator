//
// Created by Dzmitryj Bareika on 13.01.25.
//
// ax25.cpp
//#include "include/AX25Header.h"
#include "../include/AX25Header.h"
// AX25Address Implementation
AX25Address::AX25Address() : callSign(""), flags(0) {}

AX25Address::AX25Address(const etl::string<AX25_CALL_SIGN_LEN>& callSign, uint8_t flags)
    : callSign(callSign), flags(flags) {}

AX25Address AX25Address::parse(const etl::vector<uint8_t, AX25_ADDR_LEN>& data) {


  etl::string<AX25_CALL_SIGN_LEN> callSign;
  for (size_t i = 0; i < AX25_CALL_SIGN_LEN; ++i) {
    uint8_t byte = data[i];

    callSign.push_back(static_cast<char>(byte >> 1));
  }
  uint8_t flags = data[AX25_CALL_SIGN_LEN];
  return AX25Address(callSign, flags);
}

etl::vector<uint8_t, AX25_ADDR_LEN> AX25Address::encode(bool isFinal) const {
  etl::vector<uint8_t, AX25_ADDR_LEN> result;
  for (char c : callSign) {
    result.push_back(static_cast<uint8_t>(c) << 1);
  }
  result.push_back(flags | (isFinal ? AX25_FINAL_MASK : 0));
  return result;
}

std::string AX25Address::toString() const {
  return callSign.c_str();
}

// AX25Packet Implementation
AX25Packet::AX25Packet() : dstAddr(), srcAddr(), payload() {}

AX25Packet::AX25Packet(const AX25Address& dstAddr, const AX25Address& srcAddr,
                       const etl::vector<uint8_t, 256>& payload)
    : dstAddr(dstAddr), srcAddr(srcAddr), payload(payload) {}

AX25Packet AX25Packet::parse(const etl::vector<uint8_t, 512>& data) {
  size_t addrEnd = 0;
  for (size_t i = 0; i < data.size(); ++i) {
    if (data[i] & AX25_FINAL_MASK) {
      addrEnd = i + 1;
      break;
    }
  }


  etl::vector<uint8_t, AX25_ADDR_LEN> dstData(data.begin(), data.begin() + AX25_ADDR_LEN);
  etl::vector<uint8_t, AX25_ADDR_LEN> srcData(data.begin() + AX25_ADDR_LEN, data.begin() + addrEnd);

  AX25Address dstAddr = AX25Address::parse(dstData);
  AX25Address srcAddr = AX25Address::parse(srcData);


  etl::vector<uint8_t, 256> payload(data.begin() + addrEnd + 2, data.end());
  return AX25Packet(dstAddr, srcAddr, payload);
}

etl::vector<uint8_t, 512> AX25Packet::encode() const {
  etl::vector<uint8_t, 512> out;
  etl::vector<uint8_t, AX25_ADDR_LEN> encodedDstAddr = dstAddr.encode(false);
  etl::vector<uint8_t, AX25_ADDR_LEN> encodedSrcAddr = srcAddr.encode(true);

  out.insert(out.end(), encodedDstAddr.begin(), encodedDstAddr.end());
  out.insert(out.end(), encodedSrcAddr.begin(), encodedSrcAddr.end());
  out.push_back(AX25_UI_FRAME_CONTROL);
  out.push_back(AX25_UI_FRAME_PROTOCOL);
  out.insert(out.end(), payload.begin(), payload.end());
  return out;
}

std::string AX25Packet::toString() const {
  return "SRC: " + srcAddr.toString() + " DST: " + dstAddr.toString();
}

bool AX25Packet::isAddressFieldBoundaryIncorrect(size_t addrEnd) {
  return addrEnd == 0 || addrEnd % AX25_ADDR_LEN != 0;
}

// Helper Functions
AX25Address createAX25Address(const etl::string<AX25_CALL_SIGN_LEN>& callSign, uint8_t ssid, bool isCommand) {

  etl::string<AX25_CALL_SIGN_LEN> paddedCallSign = callSign;
  while (paddedCallSign.size() < AX25_CALL_SIGN_LEN) {
    paddedCallSign.push_back(' ');
  }

  uint8_t cmd = isCommand ? AX25_CMD_MASK : 0;
  uint8_t flags = AX25_RESERVED_BITS | ((ssid & AX25_SSID_MASK) << 1) | cmd;
  return AX25Address(paddedCallSign, flags);
}

AX25Packet createAX25Packet(const AX25Address& srcAddr, const AX25Address& dstAddr,
                            const etl::vector<uint8_t, 256>& payload) {
  return AX25Packet(dstAddr, srcAddr, payload);
}
