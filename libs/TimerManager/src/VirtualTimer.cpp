//
// Created by Dzmitryj Bareika on 14.02.25.
//

#include "VirtualTimer.h"

VirtualTimer::VirtualTimer(uint32_t interval_us, Callback callback, bool repeat)
    : interval(interval_us), callback(callback), repeating(repeat), active(false) {
  reset();
}

void VirtualTimer::start() {
  active = true;
  reset();
}

void VirtualTimer::stop() {
  active = false;
}

bool VirtualTimer::isActive() const {
  return active;
}

uint32_t VirtualTimer::getNextTriggerTime() const {
  return nextTriggerTime;
}

void VirtualTimer::reset() {
  nextTriggerTime = time_us_32() + interval;
}

void VirtualTimer::trigger() {
  if (active && callback) {
    callback();
  }
  if (repeating) {
    reset();
  } else {
    stop();
  }
}

VirtualTimerManager::VirtualTimerManager() {
  HardwareTimer::getInstance().start(timerCallback);
}

VirtualTimerManager& VirtualTimerManager::getInstance() {
  static VirtualTimerManager instance;
  return instance;
}

bool VirtualTimerManager::addTimer(VirtualTimer* timer) {
  if (timers.full()) {
    return false;
  }
  timers.push_back(timer);
  return true;
}

void VirtualTimerManager::removeTimer(VirtualTimer* timer) {
  for (auto it = timers.begin(); it != timers.end(); ++it) {
    if (*it == timer) {
      timers.erase(it);
      break;
    }
  }
}

void VirtualTimerManager::handleTick() {
  uint32_t now = time_us_32();
  for (auto* timer : timers) {
    if (timer->isActive() && now >= timer->getNextTriggerTime()) {
      timer->trigger();
    }
  }
}

bool VirtualTimerManager::timerCallback(struct repeating_timer *t) {
  VirtualTimerManager::getInstance().handleTick();
  return true;
}
