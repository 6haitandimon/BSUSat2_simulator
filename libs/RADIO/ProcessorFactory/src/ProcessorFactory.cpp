//
// Created by Dzmitryj Bareika on 14.02.25.
//


#include "ProcessorFactory.h"

ProcessorFactory::ProcessorFactory(uint8_t processorType) : ProcessorType(processorType) {
  this->AX25 = new AX25Processor();
  this->HDLC = new HDLCProcessor();
  this->LFSR = new LFSRProcessor();
  this->NRZI = new NRZIProcessor();

  this->AX25AddressSetup = false;
}

void ProcessorFactory::ChangeProcessorType(uint8_t processorType) {
  if(this -> ProcessorType != processorType)
    this->ProcessorType = processorType;
}

etl::vector<uint8_t, 256> ProcessorFactory::CreateRadioPacket(const etl::vector<uint8_t, 256>& payload) {
  etl::vector<uint8_t, 256> output;
  output.clear();
  if(!this->AX25AddressSetup)
    return output;

  uint8_t overSizeCheck = (payload.size() + 15) * 100 / 255;
  if(overSizeCheck > 80){
    etl::vector<uint8_t, 256> DataAX25;
    DataAX25.clear();
    this->AX25->ProcessEncode(output, DataAX25);

    return DataAX25;
  }

  etl::vector<uint8_t, 256> DataAX25;
  DataAX25.clear();
  this->AX25->ProcessEncode(payload, DataAX25);

  output = NRZI->ProcessEncode(LFSR->ProcessEncode(HDLC->ProcessEncode(DataAX25)));

  return output;
}

void ProcessorFactory::SetupAX25(const char *src_call_sign,
                                 const char *dst_call_sign) {
  delete this->AX25;
  this->AX25 = new AX25Processor(src_call_sign, dst_call_sign);

  this->AX25AddressSetup = true;
}
