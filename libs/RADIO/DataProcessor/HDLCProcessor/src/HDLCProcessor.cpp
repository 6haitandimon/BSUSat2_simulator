//
// Created by Dzmitryj Bareika on 30.01.25.
//

#include "HDLCProcessor.h"

etl::vector<uint8_t, 256> HDLCProcessor::process_viper_result(const etl::vector<uint8_t, 256> &viper_res) {
  etl::vector<uint8_t, 256> res;

  for (uint8_t byte : viper_res) {
    res.push_back(byte);
  }

  bool trail_zeros_terminated = false;

  while (!trail_zeros_terminated) {
    if (res.empty()) {
      break;
    }

    uint8_t val = res.back();
    res.pop_back();

    if (val != 0) {
      res.push_back(val);
      trail_zeros_terminated = true;
    }
  }

  return res;
}
void HDLCProcessor::stuff_bits_with_viper(const etl::vector<uint8_t, 256> &payload,
                                          etl::vector<uint8_t, 256> &output,
                                          int preamble_count,
                                          int trailer_count) {
  size_t input_size = payload.size();

  uint16_t reg = 0;
  uint8_t bit_count = 0;
  uint8_t one_count = 0;
  uint8_t mask = 0xFF;
  uint8_t val = 0;


  // Preamble processing
  for (int i = 0; i < preamble_count; i++) {
    reg <<= 8;
    reg |= HDLC_FLAG;
    val = reg >> bit_count;
    val = val & mask;
    output.push_back(static_cast<uint8_t>(val));
  }

  int last_idx = preamble_count;
  val = 0;
  reg = 0;

  uint8_t outByteIdx = 0;
  // Main cycle: Process input payload
  for (size_t byte_idx = 0; byte_idx < input_size; byte_idx++) {
    for (int bit_index = 0; bit_index < 8; bit_index++) {
      uint8_t a = payload[byte_idx] >> bit_index;
      uint8_t bit = a & 1;

      reg <<= 1;
      if (bit == 1) {
        reg |= bit;
        one_count += 1;
      } else if (bit == 0) {
        one_count = 0;
      }
      bit_count += 1;

      if (one_count == ONES_CAP) {
        reg <<= 1;
        bit_count += 1;
        one_count = 0;
      }

      if (bit_count >= 8) {
        bit_count -= 8;
        val = (reg >> bit_count) & mask;
        output.push_back(val);
        outByteIdx++;
      }
    }

  }

  last_idx += outByteIdx;

  // Trailer processing
  for (int i = 0; i < trailer_count; i++) {
    reg <<= 8;
    reg |= HDLC_FLAG;
    bit_count += 8;
    if (bit_count >= 8) {
      bit_count -= 8;
    }
    val = reg >> bit_count;
    val = val & mask;
    output.push_back(static_cast<uint8_t>(val));
  }
}

//etl::vector<uint8_t, 256>
//HDLCProcessor::ProcessEncode(const etl::vector<uint8_t, 256> &payload) {
//  etl::vector<uint8_t, 256> output;
//  output.clear();
//
//  etl::vector<uint8_t, 256> data = etl::move(payload);
//
//  uint16_t crc = Tools::crc_calc(data);
//
//
//  data.push_back(crc & 0xFF);
//  data.push_back((crc >> 8) & 0xFF);
//
//  StartEncoding(output);
//  for (uint8_t byte : data) {
//    EncodeByte(byte, output);
////    Flush(output);
//  }
//  FinishEncoding(output);
//  return output;
//}

etl::vector<uint8_t, 256>
HDLCProcessor::ProcessEncode(const etl::vector<uint8_t, 256> &payload) {
  etl::vector<uint8_t, 256> data(payload);
  size_t input_size = data.size();
//  size_t output_max_size = static_cast<size_t>(fast_ceil(input_size * 1.5)) + PREAMBLE_COUNT + TRAILER_COUNT;
  etl::vector<uint8_t, 256> output;

  uint16_t crc = Tools::crc_calc(data);

  data.push_back(crc & 0xFF);
  data.push_back((crc >> 8) & 0xFF);

  stuff_bits_with_viper(data, output, PREAMBLE_COUNT, TRAILER_COUNT);

  etl::vector<uint8_t, 256> res = process_viper_result(output);

  return res;
}


void HDLCProcessor::ProcessEncode(const etl::vector<uint8_t, 256> &payload,
                                  etl::vector<uint8_t, 256> &result) {

}
void HDLCProcessor::ProcessDecode(const etl::vector<uint8_t, 256> &payload,
                                  etl::vector<uint8_t, 256> &result) {

}



etl::vector<uint8_t, 256>
HDLCProcessor::ProcessDecode(const etl::vector<uint8_t, 256> &payload) {
  return etl::vector<uint8_t, 256>();
}
void HDLCProcessor::EncodeMarker(etl::vector<uint8_t, 256> &output) {
  reg <<= 8;
  reg |= 0x7E;
  bits += 8;
}

void HDLCProcessor::Flush(etl::vector<uint8_t, 256> &output) {
  while (bits >= 8) {
    bits -= 8;
    uint8_t data = reg >> bits;
    output.push_back(data);
  }
}

void HDLCProcessor::EncodeByte(uint8_t data,
                               etl::vector<uint8_t, 256> &output) {
  for (int i = 7; i >= 0; i--) {
    uint8_t bit = (data >> i) & 1;
    reg <<= 1;
    reg |= bit;
    bits++;

    if ((reg & 0x1F) == 0x1F) { // Добавление стафф-бита
      reg <<= 1;
      bits++;
    }

    if (bits >= 8) {
      Flush(output);
    }
  }
}
void HDLCProcessor::StartEncoding(etl::vector<uint8_t, 256> &output) {
  reg = 0;
  bits = 0;
  prefix = 7;
  suffix = 3;

  while (prefix > 0) {
    prefix--;
    EncodeMarker(output);
    Flush(output);
  }
}
void HDLCProcessor::FinishEncoding(etl::vector<uint8_t, 256> &output) {
  while (suffix > 0) {
    suffix--;
    EncodeMarker(output);
    Flush(output);
  }
}
