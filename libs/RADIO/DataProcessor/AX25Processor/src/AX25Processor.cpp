//
// Created by Dzmitryj Bareika on 30.01.25.
//


#include "AX25Processor.h"

AX25Processor::AX25Processor(const char* src_call_sign, const char* dst_call_sign){

  create_AX25_address(src_call_sign, 1, false, this->src, this->src_flag);
  create_AX25_address(dst_call_sign, 0, true, this->dst, this->dst_flag);

  encode_AX25_address(dst, dst_flag, false, encoded_dst_addr);
  encode_AX25_address(src, src_flag, true, encoded_src_addr);
}

AX25Processor::~AX25Processor() = default;

void AX25Processor::ProcessEncode(const etl::vector<uint8_t, 256>& payload, etl::vector<uint8_t, 256>& result) {
  result.insert(result.end(), encoded_dst_addr.begin(), encoded_dst_addr.end());
  result.insert(result.end(), encoded_src_addr.begin(), encoded_src_addr.end());
  result.push_back(AX25_UI_FRAME_CONTROL);
  result.push_back(AX25_UI_FRAME_PROTOCOL);
  result.insert(result.end(), payload.begin(), payload.end());
}
void AX25Processor::ProcessDecode(const etl::vector<uint8_t, 256>& payload, etl::vector<uint8_t, 256>& result) {

}

void AX25Processor::encode_AX25_address(const etl::array<char, AX25_CALL_SIGN_LEN>& call_sign, int flags, bool is_final, etl::vector<uint8_t, AX25_CALL_SIGN_LEN>& result) {
  for (size_t i = 0; i < AX25_CALL_SIGN_LEN; i++) {
    result.push_back(static_cast<uint8_t>(call_sign[i]) << 1);
  }
  result.push_back(flags | static_cast<int>(is_final));
}

bool AX25Processor::create_AX25_address(const char* cs_str, int ssid, bool is_command, etl::array<char, AX25_CALL_SIGN_LEN>& call_sign, int& flags) {
  if (!cs_str) {
    return false;
  }

  // Fill with spaces
  for (size_t i = 0; i < AX25_CALL_SIGN_LEN; i++) {
    call_sign[i] = (cs_str[i] != '\0') ? cs_str[i] : ' ';
  }

  int cmd = is_command ? AX25_CMD_MASK : 0;
  flags = AX25_RESERVED_BITS | ((ssid & AX25_SSID_MASK) << 1) | cmd;
  return true;
}
etl::vector<uint8_t, 256>

AX25Processor::ProcessEncode(const etl::vector<uint8_t, 256> &payload) {
  return etl::vector<uint8_t, 256>();
}
etl::vector<uint8_t, 256>
AX25Processor::ProcessDecode(const etl::vector<uint8_t, 256> &payload) {
  return etl::vector<uint8_t, 256>();
}

