//
// Created by Dzmitryj Bareika on 30.01.25.
//

#include "NRZIProcessor.h"

etl::vector<uint8_t, 256> NRZIProcessor::ProcessEncode(const etl::vector<uint8_t, 256> &payload) {
  uint8_t state = 1;
  etl::vector<uint8_t, 256> res;

  for (uint8_t byte : payload) {
    uint8_t hi = NRZI_ENCODE_TABLE[(byte >> 4) & 0xF];
    uint8_t lo = NRZI_ENCODE_TABLE[byte & 0xF];

    if (state != 0) {
      hi ^= 0xF;
    }
    if (hi & 1) {
      lo ^= 0xF;
    }

    state = lo & 1;
    res.push_back((hi << 4) | lo);
  }
  return res;
}
void NRZIProcessor::ProcessDecode(const etl::vector<uint8_t, 256> &payload,
                                  etl::vector<uint8_t, 256> &result) {

}
NRZIProcessor::~NRZIProcessor() {}


etl::vector<uint8_t, 256> NRZIProcessor::ProcessDecode(const etl::vector<uint8_t, 256> &payload) {
  uint8_t state = 1;
  etl::vector<uint8_t, 256> result;
  for(uint8_t byte : payload) {
    uint8_t decode_value = ~(byte ^ ((byte >> 1) | (state << 7))) & 0xFF;
    state = byte & 0x1;
    result.push_back(decode_value);
  }
  return result;
}

void NRZIProcessor::ProcessEncode(const etl::vector<uint8_t, 256> &payload,
                                  etl::vector<uint8_t, 256> &result) {}
